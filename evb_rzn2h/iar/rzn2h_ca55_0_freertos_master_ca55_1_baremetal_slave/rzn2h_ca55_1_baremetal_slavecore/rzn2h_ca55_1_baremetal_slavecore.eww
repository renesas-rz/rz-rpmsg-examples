<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\rzn2h_ca55_1_baremetal_slavecore.ewp</path>
    </project>
    <batchBuild/>
</workspace>
