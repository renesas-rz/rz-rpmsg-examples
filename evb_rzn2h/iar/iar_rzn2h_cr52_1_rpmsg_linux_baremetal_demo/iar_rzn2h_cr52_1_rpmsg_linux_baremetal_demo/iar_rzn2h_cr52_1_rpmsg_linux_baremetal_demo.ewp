# IAR project iar_rzn2h_cr52_1_rpmsg_linux_baremetal_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R9A09G087M44_R52_1 Renesas R9A09G087M44_R52_1
  General.CoreVariant: 60
  General.FPU2: 0
  ICCARM.CCDefines: VIRTIO_DEVICE_SUPPORT=1
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AExtraOptionsV2: -f "xcl/rasc_iasmarm"
  ILINK.IlinkExtraOptions: -f "xcl/rasc_ilinkarm"; --redirect Reset_Handler=system_init
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ./: buildinfo.ipcf buildinfo.ipcf
