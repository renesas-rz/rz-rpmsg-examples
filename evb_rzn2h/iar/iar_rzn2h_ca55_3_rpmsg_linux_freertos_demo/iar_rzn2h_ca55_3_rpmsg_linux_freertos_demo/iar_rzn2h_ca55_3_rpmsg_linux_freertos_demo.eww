<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\iar_rzn2h_ca55_3_rpmsg_linux_freertos_demo.ewp</path>
    </project>
    <batchBuild/>
</workspace>
