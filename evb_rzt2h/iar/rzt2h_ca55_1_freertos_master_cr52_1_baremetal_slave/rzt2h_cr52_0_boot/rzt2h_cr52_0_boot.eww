<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\rzt2h_cr52_0_boot.ewp</path>
    </project>
    <batchBuild/>
</workspace>
