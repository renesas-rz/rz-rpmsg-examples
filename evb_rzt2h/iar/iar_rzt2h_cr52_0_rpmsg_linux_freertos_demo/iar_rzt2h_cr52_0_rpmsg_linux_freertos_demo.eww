<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\iar_rzt2h_cr52_0_rpmsg_linux_freertos_demo.ewp</path>
    </project>
    <batchBuild/>
</workspace>
