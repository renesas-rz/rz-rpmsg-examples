<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\iar_rzt2h_ca55_3_rpmsg_linux_baremetal_demo.ewp</path>
    </project>
    <batchBuild/>
</workspace>
