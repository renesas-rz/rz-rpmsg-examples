<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\rzt2n_ca55_0_baremetal_mastercore.ewp</path>
    </project>
    <batchBuild/>
</workspace>
